options:
  parameters:
    generate_options: qt_gui
    id: tagged_file_sink_test
    output_language: python
    title: Tagged File Sink Test
  states: {}

blocks:
- name: burst
  id: variable_qtgui_check_box
  parameters:
    comment: |-
      Check the box to start a new burst file
      Uncheck the box to close the file
    'false': 'False'
    gui_hint: 0,0,1,1
    'true': 'True'
    type: bool
    value: 'False'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: tuning
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: 70e6
    step: 200e4
    stop: 3000e6
    value: 98.2e6
  states: {}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    gui_hint: 1,0,1,1
    label: Check the box to start a new burst file
    type: string
    value: ''
  states: {}
- name: variable_qtgui_label_0_0
  id: variable_qtgui_label
  parameters:
    gui_hint: 2,0,1,1
    label: Uncheck the box to close the file
    type: string
    value: ''
  states: {}
- name: block_test_bursts
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, burst=False):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              
              self.burst = burst
              self.burst_state = True

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              
              if self.burst != self.burst_state:        
                  self.burst_state = self.burst
              
                  key = pmt.intern("burst")
                  value = pmt.from_bool(self.burst_state)
                  self.add_item_tag(0, self.nitems_written(0), key, value)
                  self.burst_state = not(self.burst_state)
              
              output_items[0][:] = input_items[0] 
              return len(output_items[0])
    burst: burst
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.cons(pmt.intern("freq"),pmt.from_double(93e6))
    period: '20000'
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: complex
  states: {}
- name: blocks_tagged_file_sink_0
  id: blocks_tagged_file_sink
  parameters:
    samp_rate: int(samp_rate)
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: tuning
    fftsize: '1024'
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    bw0: samp_rate
    center_freq0: tuning
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: '50'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [block_test_bursts, '0', blocks_tag_debug_0, '0']
- [block_test_bursts, '0', blocks_tagged_file_sink_0, '0']
- [block_test_bursts, '0', qtgui_sink_x_0, '0']
- [block_test_bursts, '0', qtgui_time_sink_x_0, '0']
- [blocks_message_strobe_0, strobe, uhd_usrp_source_0, command]
- [uhd_usrp_source_0, '0', block_test_bursts, '0']

metadata:
  file_format: 1
