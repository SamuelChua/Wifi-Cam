options:
  parameters:
    generate_options: no_gui
    id: extract_no_gui
    output_language: python
    run_options: run
    title: Extract_No GUI
  states: {}

blocks:
- name: duration
  id: variable
  parameters:
    value: '5'
  states: {}
- name: prefix
  id: variable
  parameters:
    value: '''C:\\Users\\intern\\Documents\\GitHub\\Wifi-Cam\\signal_data\\filename'''
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: time
  id: variable
  parameters:
    value: prefix + datetime.now().strftime("%H.%M.%S")
  states: {}
- name: veclength
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: veclength
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: time
    type: float
    vlen: veclength
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: '10240000'
    type: complex
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: '100'
    type: float
    vlen: veclength
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: veclength
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: veclength
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(1024)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from datetime import datetime
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    bw0: samp_rate
    center_freq0: 2.4118e9
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: '50'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_integrate_xx_0, '0']
- [blocks_head_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_integrate_xx_0, '0', blocks_file_sink_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [uhd_usrp_source_0, '0', blocks_head_0, '0']

metadata:
  file_format: 1
