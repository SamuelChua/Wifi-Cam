options:
  parameters:
    generate_options: hb
    id: Custom_File_Sink
    output_language: python
    title: Custom File Sink
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: time
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}

connections:
- [pad_source_0, '0', blocks_file_sink_0, '0']
- [pad_source_0, '0', blocks_null_sink_0, '0']

metadata:
  file_format: 1
