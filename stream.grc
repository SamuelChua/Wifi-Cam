options:
  parameters:
    generate_options: qt_gui
    id: stream
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: trigger
  id: variable
  parameters:
    value: '-1'
  states: {}
- name: tuning
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: 70e6
    step: 200e4
    stop: 3000e6
    value: 98.2e6
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: trigger
    type: short
  states: {state: disabled}
- name: blocks_burst_tagger_0
  id: blocks_burst_tagger
  parameters:
    false_key: burst
    false_value: 'False'
    true_key: burst
    true_value: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: record
    type: complex
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.cons(pmt.intern("freq"),pmt.from_double(93e6))
    period: '20000'
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: int(samp_rate)
    type: complex
  states: {state: disabled}
- name: blocks_tagged_file_sink_0
  id: blocks_tagged_file_sink
  parameters:
    samp_rate: int(samp_rate)
    type: complex
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt
       
      class blk(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(self,name='Read Tags', in_sig=[np.float32], out_sig=[np.float32])
       
          def work(self, input_items, output_items):
              tags = self.get_tags_in_window(0, 0, len(input_items[0]))
              for tag in tags:
                  key = pmt.to_python(tag.key) # convert from PMT to python string
                  value = pmt.to_python(tag.value) # Note that the type(value) can be several things, it depends what PMT type it was
                  print ('key:', key)
                  print ('value:', value, type(value))
                  print ('')
              return len(input_items[0])
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr, uhd
      import time

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, example_param=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Issue Stream Cmds',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.example_param = example_param

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = input_items[0] * self.example_param
              count = 0 
              num_samples = 1000000*1
              while (count < 5):
                  time.sleep(1.0)
                  uhd.usrp_source_sptr.clear_command_time(self)
                  uhd.usrp_source_sptr.get_time_now()
                  uhd.usrp_source_sptr.set_command_time(now_time + uhd.time_spec.from_ticks(2,1.0)) 
                  uhd.usrp_source_sptr.issue_stream_cmd(num_samples)
              count += 1
              time.sleep(2) 
              return len(output_items[0])
    example_param: '1.0'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: tuning
    fftsize: '1024'
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"burst"'
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    bw0: samp_rate
    center_freq0: tuning
    dev_args: '""'
    gain0: '50'
    len_tag_name: tx_pkt_len
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    bw0: samp_rate
    center_freq0: uhd.tune_request(tuning, 10e6)
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: '50'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_burst_tagger_0, '1']
- [blocks_burst_tagger_0, '0', blocks_tagged_file_sink_0, '0']
- [blocks_burst_tagger_0, '0', qtgui_sink_x_0, '0']
- [blocks_burst_tagger_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_float_0, '0', epy_block_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_message_strobe_0, strobe, qtgui_sink_x_0, freq]
- [blocks_message_strobe_0, strobe, uhd_usrp_source_0, command]
- [blocks_stream_to_tagged_stream_0, '0', blocks_complex_to_float_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_tagged_file_sink_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', qtgui_sink_x_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', uhd_usrp_sink_0, '0']
- [epy_block_0, '0', blocks_float_to_complex_0, '0']
- [epy_block_1, '0', blocks_file_sink_0, '0']
- [epy_block_1, '0', qtgui_sink_x_0, '0']
- [epy_block_1, '0', qtgui_time_sink_x_0, '0']
- [uhd_usrp_source_0, '0', blocks_burst_tagger_0, '0']
- [uhd_usrp_source_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [uhd_usrp_source_0, '0', epy_block_1, '0']

metadata:
  file_format: 1
