options:
  parameters:
    generate_options: qt_gui
    id: stream
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: tuning
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: 70e6
    step: 200e4
    stop: 3000e6
    value: 98.2e6
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.cons(pmt.intern("freq"),pmt.from_double(93e6))
    period: '20000'
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: int(samp_rate)
    type: complex
  states: {}
- name: blocks_tagged_file_sink_0
  id: blocks_tagged_file_sink
  parameters:
    samp_rate: int(samp_rate)
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt
       
      class blk(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(self,name='Read Tags', in_sig=[np.float32], out_sig=[np.float32])
       
          def work(self, input_items, output_items):
              tags = self.get_tags_in_window(0, 0, len(input_items[0]))
              for tag in tags:
                  key = pmt.to_python(tag.key) # convert from PMT to python string
                  value = pmt.to_python(tag.value) # Note that the type(value) can be several things, it depends what PMT type it was
                  print ('key:', key)
                  print ('value:', value, type(value))
                  print ('')
              return len(input_items[0])
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: tuning
    fftsize: '1024'
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    bw0: samp_rate
    center_freq0: tuning
    dev_args: '""'
    gain0: '50'
    len_tag_name: tx_pkt_len
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    bw0: samp_rate
    center_freq0: uhd.tune_request(tuning, 10e6)
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: '50'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_complex_to_float_0, '0', epy_block_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_message_strobe_0, strobe, qtgui_sink_x_0, freq]
- [blocks_message_strobe_0, strobe, uhd_usrp_source_0, command]
- [blocks_stream_to_tagged_stream_0, '0', blocks_complex_to_float_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_tagged_file_sink_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', qtgui_sink_x_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', uhd_usrp_sink_0, '0']
- [epy_block_0, '0', blocks_float_to_complex_0, '0']
- [uhd_usrp_source_0, '0', blocks_stream_to_tagged_stream_0, '0']

metadata:
  file_format: 1
