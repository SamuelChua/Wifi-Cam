options:
  parameters:
    generate_options: qt_gui
    id: Test
    output_language: python
    title: FM_Record
  states: {}

blocks:
- name: channel_width
  id: variable
  parameters:
    value: 250e3
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: Rf Gain
    orient: Qt.Horizontal
    start: '30'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    label: Sample Rate
    orient: Qt.Horizontal
    start: 192e3
    step: '1000'
    stop: 56e6
    value: 1e6
  states: {}
- name: tuning
  id: variable_qtgui_range
  parameters:
    label: Frequency
    orient: Qt.Horizontal
    start: 70e6
    step: 200e3
    stop: 6e9
    value: 98.7e6
  states: {}
- name: tx_onoff
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    label: TX On/Off
    'true': 'True'
    type: int
    value: 'False'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: channel_width
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '96000'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: int(samp_rate*10)
    type: complex
  states: {state: disabled}
- name: blocks_mute_xx_0
  id: blocks_mute_xx
  parameters:
    mute: tx_onoff
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: int(samp_rate)
    type: complex
  states: {state: disabled}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '8'
    file: fm_record
    samp_rate: '96000'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt, time, threading


      class txrx(gr.basic_block):
          """
          docstring for block txrx
          """
          def __init__(self):
              gr.basic_block.__init__(self,
                  name="txrx",
                  in_sig=None,
                  out_sig=None)
              self.time_count = 5 #initial timestamp to allow for setup time
              self.current_freq = 100000000
              self.message_port_register_out(pmt.intern("rx_cmd"))
              threading.Thread(target=self.send_rx_cmd).start()
              
          def send_rx_cmd(self):
          	time.sleep(1)
          	count = 0 
          	while (count < 10000):
          	    self.time = pmt.cons(
          	    pmt.from_uint64(int(self.time_count)),
          	    pmt.from_double((self.time_count) % 1),
          	)
          	rx_cmd = pmt.make_dict()
          	rx_cmd = pmt.dict_add(rx_cmd, pmt.intern('time'), self.time)
          	rx_cmd = pmt.dict_add(rx_cmd, pmt.intern('freq'), pmt.from_double(self.current_freq))
          	self.message_port_pub(pmt.intern('rx_cmd'),rx_cmd)
          	count += 1
          	self.time_count += 0.5
          	self.current_freq = 100000000 - 500000 + 100000*(count%2)
          	time.sleep(2) 
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 100e3
    decim: int(samp_rate/channel_width)
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: tuning
    fftsize: '1024'
    name: Spectrum
    rate: '15'
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: tuning
    fftsize: '1024'
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '96'
    interp: '250'
    taps: ''
    type: fff
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    bw0: samp_rate
    center_freq0: current_freq
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: rf_gain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: uhd_usrp_source_1
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    bw0: samp_rate
    center_freq0: uhd.tune_request(9e7,0)
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: rf_gain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0, '0']
- [blocks_delay_0, '0', qtgui_sink_x_0, '0']
- [blocks_mute_xx_0, '0', qtgui_sink_x_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', qtgui_sink_x_1, '0']
- [epy_block_0, rx_cmd, uhd_usrp_source_0, command]
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']
- [rational_resampler_xxx_0, '0', blocks_wavfile_sink_0, '0']
- [uhd_usrp_source_0, '0', blocks_mute_xx_0, '0']
- [uhd_usrp_source_0, '0', low_pass_filter_0, '0']
- [uhd_usrp_source_1, '0', qtgui_sink_x_1, '0']

metadata:
  file_format: 1
