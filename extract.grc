options:
  parameters:
    generate_options: qt_gui
    id: extract
    output_language: python
    title: Extract
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: tuning
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: 70e6
    step: 200e4
    stop: 3000e6
    value: 98.2e6
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: '0'
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: '0'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    timeout: '100'
    type: complex
  states: {}

connections:
- [uhd_usrp_source_0, '0', zeromq_push_sink_0, '0']

metadata:
  file_format: 1
