options:
  parameters:
    generate_options: qt_gui
    id: extract
    output_language: python
    run_options: run
    title: Extract
  states: {}

blocks:
- name: Switch
  id: variable_qtgui_chooser
  parameters:
    label0: 'Off'
    label1: 'On'
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
  states: {}
- name: button
  id: variable_qtgui_push_button
  parameters:
    label: 'On/Off '
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {state: disabled}
- name: duration
  id: variable
  parameters:
    value: '1'
  states: {}
- name: prefix
  id: variable
  parameters:
    value: '''C:\\Users\\intern\\Documents\\GitHub\\Wifi-Cam\\signal_data\\filename'''
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: time
  id: variable
  parameters:
    value: prefix + datetime.now().strftime("%H.%M.%S")
  states: {}
- name: tuning
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: 70e6
    step: 2e6
    stop: 3e9
    value: 2.422e9
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: '0'
    threshold: '-140'
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: time
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: Switch
    type: complex
  states: {state: disabled}
- name: blocks_mute_xx_0
  id: blocks_mute_xx
  parameters:
    mute: 'True'
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    Num_Samples_To_Count: int(samp_rate*duration)
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, Num_Samples_To_Count = 128):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='True/False',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.Num_Samples_To_Count = Num_Samples_To_Count
              self.portName = "MessageOutput"
              self.message_port_register_out(pmt.intern(self.portName))
              self.state = True
              self.counter = 0

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = input_items[0] 
              self.counter = self.counter + len(output_items[0])

              if (self.counter > self.Num_Samples_To_Count):
                  PMT_msg = pmt.from_bool(self.state)
                  self.message_port_pub(pmt.intern(self.portName), PMT_msg)
                  self.state = not(self.state)
                  self.counter = 0

              return len(output_items[0])
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from datetime import datetime
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: tuning
    fftsize: '1024'
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    bw0: samp_rate
    center_freq0: tuning
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: '50'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_pwr_squelch_xx_0, '0', blocks_file_sink_0, '0']
- [analog_pwr_squelch_xx_0, '0', qtgui_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', analog_pwr_squelch_xx_0, '0']
- [blocks_mute_xx_0, '0', analog_pwr_squelch_xx_0, '0']
- [epy_block_0, '0', blocks_mute_xx_0, '0']
- [epy_block_0, MessageOutput, blocks_message_debug_0, print]
- [epy_block_0, MessageOutput, blocks_mute_xx_0, set_mute]
- [uhd_usrp_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [uhd_usrp_source_0, '0', epy_block_0, '0']

metadata:
  file_format: 1
